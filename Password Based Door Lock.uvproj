# Keil uVision project Password Based Door Lock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: i2c_new_interrupt +hex
  c flags: Optimize=8 SizeSpeed=1
  group Application
    ./Application/: main.c
  group DriverCode
    ./driverCode/: compare_password.c delay.c dummy_fun.c edit_pass.c eeprom.c enter_password.c frame.c hello.c init_pass_read_eeprom.c init_pass_write_eeprom.c initialize_inturrupt.c INT0.c int0.h keypad.c lcd1.c motor.c pass.c read.c select_id.c strcmp.c system_block.c taking_id.c uart.c welcome_Screen.c
    ./driverCode/../include/: app_api.h
